FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SPLASH_IMAGES_append = "file://psplash-poky-img.h;outsuffix=default"