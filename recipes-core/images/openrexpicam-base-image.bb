DESCRIPTION = "Basic image openrexpicam"
LICENSE = "MIT"

#inherit openrexpicam-base-image
#IMAGE_INSTALL += " \
#        gstreamer \
#"
